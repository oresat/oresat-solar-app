## boards/mcxn947_solar_card/board.yml
```yaml
board:
  name: mcxn947_solar_card
  full_name: Oresat MCXN947 Solar Card
  vendor: PSAS
  socs:
    - name: mcxn947
```
